Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:09:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:09:19 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\8642f00c-7ea5-4783-9cf0-9ddba99623e9\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:09:14 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:09:15 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:09:15 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 44630300 Hand shower, 44630300:44630300 Hand shower:485606
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 59 mm; NominalHeight: 242.9 mm; NominalWidth: 95 mm
Type - General - Author: BIMStone; BIMObjectName: 44630300; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval ABP: P-IX 29949/IA; Approval DVGW: DW-6517CT0297; EAN Number: 4057304002441; EN Standard: EN 1112; ETIM Class Number: EC010161 Hand shower; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 242.0 x 95.0 x 47.0; UNSPSC Class Number: 30181503 Showers; URL ABP: http://static.hansa.com/ABP/44630300; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/44630300; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/44630300; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/44630300
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/44630300; 3D View: https://static.hansa.com/3D/44630300; Catalog Drawing URL: http://static.hansa.com/catdrw/44630300; Category B2B: Accessories; Category B2C: Shower solutions; Color variants: 4463030033; Dimension Drawing URL: http://static.hansa.com/dimdrw/44630300; FDV Document URL: http://www.hansa.com/datasheet/44630300/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/44630300; Group: Hand shower; Installation and Maintenance Guide URL: http://static.hansa.com/manual/44630300; Interactive AR View URL: https://static.hansa.com/AR/44630300; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/44630300; Model: 44630300 Hand shower; Name_en: 44630300 Hand shower; OmniClass Number: 23.45.55.00; Product Code: 44630300; Product Family: HANSABASICJET; Product Image URL: http://static.hansa.com/image/44630300; Product URL: http://static.hansa.com/44630300; Replacement to: 44630100;44340100; Technical DataSheet URL: http://www.hansa.com/datasheet/44630300/en; Type Name: 44630300 Hand shower; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Connection Size: G1/2; Eco Flow At 300kPa: 0.0052972 m3/s; Flow Rate At 300kPa: 0.0105944 m3/s; Flow Rate At 300kPa With Flow Controller: 0 m3/s; Hand Shower Size: Ø 95 mm; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Eco flow control;Anti limescale technology (easy to clean); Shower Spray: Normal - Even and soft water stream;Refreshing - Strong water stream, activates and refreshes body;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 44630300; Features: n/a; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 44630300; Name: 44630300 Hand shower; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 44630300 Hand shower; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 44630300; Manufacturer: HANSA
Pset_ProductRequirements - Name: 44630300 Hand shower; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0430133 m2; Volume: 0.00136184 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 44630300: 44630300 Hand shower; Family and Type: 44630300: 44630300 Hand shower; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 44630300: 44630300 Hand shower; Type Id: 44630300: 44630300 Hand shower; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
